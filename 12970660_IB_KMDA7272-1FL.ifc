Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 4969e192-be45-4034-a5f1-edc85054a03d, NumberOfSaves: 1]
File name: 0001
Time: 2025-10-22T10:46:05+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12970660_IB_KMDA7272-1FL:26727275_IB_12970660_KMDA7272-1FL, (2)
In: Default
Type - Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_OBSW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 800 mm; Height: 200 mm; Depth: 520 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 26727275_IB_12970660_KMDA7272-1FL; sets with these values: 2
